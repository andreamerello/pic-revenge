## k8048/Src/gpio-bb/module/src/Kconfig
```kconfig
config GPIO_BIT_BANG
    tristate "GPIO bit-bang"
    depends on GENERIC_GPIO
    select GPIO_BIT_BANG
    help
      GPIO bit-bang driver
```
